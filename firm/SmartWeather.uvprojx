# Keil uVision project SmartWeather.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartWeather +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: .\middlewares\FreeRTOS\Source\include;.\middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\middlewares;.\config;.\application\hw_driver;.\application\tasks;.\application\wrapper;.\application\managers;.\RTE\Device\TM4C123GH6PM;.\drivers\TivaWare_C_Series-2.2.0.295\tools;.\drivers\TivaWare_C_Series-2.2.0.295\inc;.\drivers\TivaWare_C_Series-2.2.0.295\utils;.\drivers\TivaWare_C_Series-2.2.0.295\driverlib;..\..\..\..;.\components;.\components\filter;.\components\linked_list
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ./application/: main.c Retarget.c
  group application/managers
    ./application/managers/: SensorManager.c
  group application/tasks
    ./application/tasks/: BlinkTask.c SensorTask.c
  group application/wrapper
    ./application/wrapper/: WrapperRTOS.c
  group application/hw_driver
    ./application/hw_driver/: gpio_driver.c sysclk_driver.c uart_driver.c uc_driver.c adc_driver.c OneWire.c
  group config
    ./config/: FreeRTOSConfig.h
  group middleware
    ./middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group RTE/Device
    ./RTE/Device/TM4C123GH6PM/: startup_rvmdk.S
  group drivers
    ./drivers/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
  group components
    ./components/filter/: filter.c
    ./components/linked_list/: linked_list.c
software components: CMSIS:CORE 5.4.0
